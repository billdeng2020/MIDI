# Keil uVision project main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\drive;.\modules\nrfx\hal;.\modules\nrfx;.\integration\nrfx;.\components\libraries\util;.\components\softdevice\s112\headers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c
  group drive
    ./drive/: led.c
  group ::Device
    RTE/Device/nRF52840_xxAA/: arm_startup_nrf52840.s system_nrf52840.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.16.0
